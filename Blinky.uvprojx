# Keil uVision project Blinky.uvprojx, settings and files
target XMC4300 Relax Kit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4300-F100x256 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IROM(0x08000000,0x40000) IROM2(0x0C000000,0x40000) IRAM(0x20000000,0x0FFC0) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\code
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./code/: USIC.c GPIOs.c m.c TheTime.c AD5761.c BoardDev.c AD8694.c Str.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.2.4
